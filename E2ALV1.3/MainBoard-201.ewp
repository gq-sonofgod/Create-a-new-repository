# IAR project MainBoard-201.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207C8 STM8S207C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: ET223_CM_ANTI; STM8S007; RAM_EXECUTION
  ICCSTM8.CCIncludePath2: FWLib\inc; FWLib\src; USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MainBoard-201.hex
  ILINK.IlinkOutputFile: MainBoard-201.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  General.GenCodeModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG; H1230; L60; CM; STM8S007; RAM_EXECUTION
  group FWLib
    FWLib/src/: stm8s_adc2.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c
  group USER
    USER/: ADC.c Balance.c CRC16.c Delay.c EEPROM.c EXTI.c FaultDetection.c HealthMode.c Key.c LED.c LSM6DSL.c lsm6dsl_reg.c Main.c Motor.c PID.c PortToPC.c stm8s_it.c Tap.c Timer.c Uart.c
