<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>FWLib</name>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_adc2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\src\stm8s_uart3.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\USER\ADC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Balance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\CRC16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\EEPROM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\EXTI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\FaultDetection.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\HealthMode.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\LED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\LSM6DSL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\lsm6dsl_reg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\PortToPC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Tap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Uart.c</name>
    </file>
  </group>
</project>


